# Keil uVision project ghj.uvprojx, settings and files
target Target 1 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: ghj +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\CoreSupport;.\CMSIS\DeviceSupport\ST\STM32F10x
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Startup
    ./CMSIS/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group MainCode
    ./: main.c
  group CMSIS
    ./CMSIS/CoreSupport/: core_cm3.c
    ./CMSIS/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
